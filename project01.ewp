# IAR project project01.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenDeviceSelect: R5F10RLC RL78 - R5F10RLC
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 128
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  General.GenHugeHeapSize: 0
  ICCRL78.IccLang: 0
  ILINK.IlinkOutputFile: project01.out
  ILINK.IlinkConfigDefines: __RESERVE_OCD_ROM=1; __RESERVE_OCD_TRACE_RAM=0; __RESERVE_HOTPLUGIN_RAM=0
  ILINK.IlinkStackSize: 1
  ILINK.IlinkNearHeapSize: 1
  ILINK.IlinkFarHeapSize: 1
  ILINK.IlinkHugeHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RL78)
  as the first configuration, except:
  ICCRL78.CCDefines: NDEBUG
  group (top)
    prj01/pro01/applilet3_src/: r_cg_cgc.c r_cg_cgc.h r_cg_cgc_user.c r_cg_intc.c r_cg_intc.h r_cg_intc_user.c r_cg_lcd.c r_cg_lcd.h r_cg_lcd_user.c r_cg_macrodriver.h r_cg_port.c r_cg_port.h r_cg_port_user.c r_cg_timer.c r_cg_timer.h r_cg_timer_user.c r_cg_userdefine.h r_cg_wdt.c r_cg_wdt.h r_cg_wdt_user.c r_main.c r_systeminit.c
